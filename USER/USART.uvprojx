# Keil uVision project USART.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\USMART;..\MALLOC;..\HARDWARE\SD;..\HARDWARE\exfuns;..\HARDWARE\FLASH;..\HARDWARE\RTC;..\HARDWARE\SPI;..\HARDWARE\exfuns\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/MPU6050/: mpu6050.h mpuiic.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/exfuns/: exfuns.c fattester.c
    ../HARDWARE/exfuns/src/option/: cc936.c
    ../HARDWARE/exfuns/src/: diskio.c ff.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
    ../MALLOC/: malloc.c
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group README
    ../: README.TXT
